# Repository svofski/tapeshnik

File README.md:

# Tapeshnik

Compact cassette data drive.

Project goals. Not all of them are realistic.

  * utilize an existing consumer tape mechanism with "logic control" to make a fully automatic tape drive
  * investigate the limits of what can be done with a simple compact cassette
  * implement random access to sectors
  * a usb mass storage device
  * use a stereo track for double data rate access, eventually use a 4-track head for quad data rate
  * investigate if altering motor speed to improve r/w speeds makes sense
  * investigate feasibility of reading while fast-forwarding with heads half-lifted

Eventually it's doomed to become either a dust gatherer/conversation piece or an art installation.

# Notes

There is no blog, but there are project notes, updated sometimes: [NOTES](docs/NOTES.md)

Note on the second iteration of Tapeshnik: [FUTURISTIC](docs/FUTURISTIC.md)

There is also a [youtube playlist](https://www.youtube.com/playlist?list=PLuOXWyWDhULNxkAvCRtwkEgnuxFfULnF9), where I try to show noteworthy things about this project. Like/subscribe!

## KiCad design hardware/tapeshnik-mecha/pwm3389_pcb_edge/pwm3389_pcb_edge.kicad_pcb

File hardware/tapeshnik-mecha/pwm3389_pcb_edge/README.md:

# PWM3389-TAPESHNIK

This is a PWM3389 adapter board for use in TAPESHNIK. It is not intended for a general purpose mouse implementation.

The design is based on SideraKB's PMW3360-PCB https://github.com/siderakb/pmw3360-pcb

Parts:
C1: 4.7uF/10V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J2: Conn_01x07; EDGE-2.54-7x
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R2: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 39R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 28k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 56.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1: VIO; TestPoint_Pad_D1.5mm
TP2: VDD; TestPoint_Pad_D1.5mm
TP3: GND; TestPoint_Pad_D1.5mm
U1: PMW3360DM-T2QU; PMW3360DM-T2QU 16Pin
U2: TPS73601DBV; SOT-23-5

Connections:
/CS: J2.4, U1.13 (~CS)
/MISO: J2.7, R2.2, U1.12 (MISO)
/MOSI: J2.6, U1.11 (MOSI)
/MOTION: U1.9 (MOTION)
/RESET: J2.3, R1.2, U1.7 (~RESET)
/SCLK: J2.5, U1.10 (SCLK)
GND: C1.2, C2.2, C3.2, C4.2, J2.2, R5.2, TP3.1, U1.8 (GND), U2.2 (GND)
unnamed: R3.2, U1.15 (LED_P)
unnamed: C1.1, C2.1, U1.3 (VDDPIX)
unnamed: R4.2, R5.1, U2.4 (FB)
VDD: C4.1, R3.1, R4.1, TP2.1, U1.4 (VDD), U2.5 (OUT)
V_{IN}: C3.1, J2.1, R1.1, R2.1, TP1.1, U1.5 (VDDIO), U2.1 (IN), U2.3 (EN)

Notes on the sheet:
Reserved, ~{RESET} pin has a built in weak pull up circuit.
LDO can be replaced by SPX3819M5-1.8V: - R4, R5 don't install
Operating Voltage Range VIN: 2.0~5.5V, must be same or greater than V_{DD} + 0.2V VDD: 1.8~2.1V, Typ. 1.9V VIO: 1.8~3.6V, Typ. 1.9V, must be same or greater than V_{DD}
LDO can be replace by RT9193-18GB: - Change C3 and C4 to 1uF. - Change R5 to a 22nF or larger ceramic capacitor. - R4 don't install.
Test Points
Power

Board: 2 copper layers, 22.8 x 23.9 mm, 15 parts (5 on the bottom side), 11 nets.

## KiCad design hardware/tapeshnik-mecha/platen-heads/platen-heads.kicad_pcb

File hardware/tapeshnik-mecha/platen-heads/README.md:

# TAPESHNIK-MECHA Heads Platen

This is platen #2 of the TAPESHNIK-MECHA.

Parts:
J1: Conn_01x07; EDGE-2.54-7x
J2: Conn_01x07; JST_SH_SM07B-SRSS-TB_1x07-1MP_P1.00mm_Horizontal
J3: Conn_01x09; JST_SH_SM09B-SRSS-TB_1x09-1MP_P1.00mm_Horizontal
J4: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical

Connections:
GND: J1.2, J2.2, J3.9, J4.9
unnamed: J1.1, J2.1
unnamed: J1.3, J2.3
unnamed: J1.4, J2.4
unnamed: J1.5, J2.5
unnamed: J1.6, J2.6
unnamed: J1.7, J2.7
unnamed: J3.1, J4.1
unnamed: J3.2, J4.2
unnamed: J3.3, J4.3
unnamed: J3.4, J4.4
unnamed: J3.5, J4.5
unnamed: J3.6, J4.6
unnamed: J3.7, J4.7
unnamed: J3.8, J4.8

Board: 2 copper layers, 137.6 x 83.0 mm, 4 parts (0 on the bottom side), 15 nets.

## KiCad design hardware/tapeshnik-proto2/tapeshnik-proto.kicad_pcb

Parts:
C1, C5, C11, C15, C22: 0.1u; C_0805_2012Metric; LCSC C49678
C2, C12: 180p; C_0805_2012Metric
C3, C13: 2200p; C_0805_2012Metric; LCSC C28260
C4, C14: 150p; C_0805_2012Metric
C6, C7, C17, C18, C21: 10.0u/25V; C_0805_2012Metric
C8, C9, C10, C16, C19, C20: 0.1u; C_0603_1608Metric; LCSC C14663
C23, C25: 220.0/16V; CP_EIA-7343-31_Kemet-D
C24: 47.0/16V; CP_EIA-3528-21_Kemet-B
D1, D2, D3, D4: BAT54S; SOT-23
D5: red; LED_0603_1608Metric
D6, D7: green; LED_0603_1608Metric
D8: orange; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2, J5: RW_HEAD; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J4: ERASERHEAD; PinHeader_1x02_P2.54mm_Vertical
J6, J7, J8, J9: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
J10: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
JP1, JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged2Bar_Pad1.0x1.5mm
Q1, Q2, Q4, Q6: AO3400; SOT-23
Q3, Q7: S8050; SOT-23
Q5, Q8: AO3401; SOT-23
R1, R12, R32, R37: 100K; R_0805_2012Metric
R2, R3, R62, R63: 47; R_0805_2012Metric
R4, R64: 22K; R_0805_2012Metric
R5, R8, R9, R22, R24, R34, R35, R36, R51, R52: 10K; R_0805_2012Metric
R6, R7, R30, R31, R38, R40, R60: 470; R_0805_2012Metric
R10, R17, R39, R46: 330K; R_0805_2012Metric
R11, R16, R21, R41, R45, R50: 2K7; R_0805_2012Metric
R13, R42: 6K8; R_0805_2012Metric
R14, R15, R20, R43, R44, R48: 47K; R_0805_2012Metric
R18, R47: 3K9; R_0805_2012Metric
R19, R49: 56K; R_0805_2012Metric
R23, R55: 2M2; R_0805_2012Metric
R25, R29, R56: 1K; R_0805_2012Metric
R26: 3K3; R_0805_2012Metric
R27: 2K2; R_0805_2012Metric
R28: 220; R_0805_2012Metric
R33, R57, R58, R59: N/C; R_0805_2012Metric
R53, R54, R66: 4K7; R_0805_2012Metric
R61: 680; R_0805_2012Metric
TP1, TP2: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
U1: Pico; RPi_Pico_SMD_TH
U2, U9: 74HC14; SOIC-14_3.9x8.7mm_P1.27mm
U3, U6: 74HC4052D; SO-16_3.9x9.9mm_P1.27mm
U4, U5, U8, U10: LM358; SO-8_3.9x4.9mm_P1.27mm
U7: AMS1117-5.0; SOT-223-3_TabPin2
U11: REF3030; SOT-23
U12: SPX3819M5-L-5-0; SOT-23-5

Connections:
+3V3: D2.2 (K), D4.2 (K), J3.6, J10.7, R53.2, R54.2, U1.36 (3V3), U11.1 (IN)
+5V: C6.1, C8.2, C9.2, C10.2, C16.2, C19.2, C20.2, C21.1, C24.1, R6.2, R7.2, R25.1, R26.2, R28.1, R38.2, R40.2, R56.1, R61.2, U2.14 (VCC), U3.16 (VDD), U4.8 (V+), U5.8 (V+), U6.16 (VDD), U7.2 (VO), U8.8 (V+), U9.14 (VCC), U10.8 (V+), U12.5 (OUT)
+12V: C18.1, C23.1, C25.1, D1.3 (COM), J1.1, J9.1, Q5.2 (S), R4.2, U7.3 (VI), U12.1 (IN), U12.3 (EN)
/ADC1: R58.2, U1.32 (GPIO27_ADC1)
/ADC2: R59.2, U1.34 (GPIO28_ADC2)
/CAS_ERASE: R29.2, U1.16 (GPIO12)
/CAS_MODE: J3.2, U1.29 (GPIO22)
/CAS_PRESENT: J3.7, U1.15 (GPIO11)
/CAS_RD1: Q4.3 (D), R53.1, TP1.1, U1.22 (GPIO17)
/CAS_RD2: Q6.3 (D), R54.1, TP2.1, U1.19 (GPIO14)
/CAS_SOL: D3.2 (K), J3.3, Q5.3 (D)
/CAS_TACHO: J3.5, U1.25 (GPIO19)
/CAS_WR1: U1.21 (GPIO16), U2.11
/CAS_WR2: U1.20 (GPIO15), U9.11
/CAS_WRPROTEC: J3.1, U1.14 (GPIO10)
/CAS_WRSEL1: R62.1, U1.24 (GPIO18)
/CAS_WRSEL2: R63.1, U1.17 (GPIO13)
/EBOOST: J10.1, R66.1, U1.9 (GPIO6)
/LED_ACTIVITY: R60.2, U1.12 (GPIO9)
/LED_READ: R31.2, U1.11 (GPIO8)
/LED_WRITE: R30.2, U1.10 (GPIO7)
/MOTOR: D4.3 (COM), R3.1, U1.27 (GPIO21)
/SOLENOID: D2.3 (COM), R2.1, U1.26 (GPIO20)
/VBUS: Q8.2 (S), R64.2, U1.40 (VBUS)
/VBUSSEQ: C17.1, J6.1, Q8.3 (D)
/VIRTGND: C6.2, C7.1, R12.2, R14.2, R20.2, R22.1, R24.1, R26.1, R27.2, R37.2, R43.2, R48.2, R51.1, R52.1
GND: C7.2, C8.1, C9.1, C10.1, C16.1, C19.1, C20.1, C21.2, C22.1, C24.2, H3.1, J2.2, J5.2, JP2.2 (B), Q3.2 (E), Q4.2 (S), Q6.2 (S), R11.2, R16.2, R21.2, R27.1, R33.2, R41.2, R45.2, R50.2, R57.2, U1.33 (AGND), U2.7 (GND), U3.2 (Y2), U3.4 (Y3), U3.6 (INH), U3.7 (VEE), U3.8 (VSS), U3.9 (B), U3.11 (X3), U3.15 (X2), U4.4 (V-), U5.4 (V-), U6.2 (Y2), U6.4 (Y3), U6.6 (INH), U6.7 (VEE), U6.8 (VSS), U6.9 (B), U6.11 (X3), U6.15 (X2), U7.1 (GND), U8.4 (V-), U9.7 (GND), U10.4 (V-), U11.3 (GND), U12.2 (GND)
GNDD: C18.2, C23.2, C25.2, D2.1 (A), D3.3 (COM), D4.1 (A), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), H1.1, H2.1, H4.1, J3.4, J8.1, J10.2, JP1.1 (A), JP2.1 (A), Q1.2 (S), Q2.2 (S), Q7.2 (E), R1.2, R32.2, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.38 (GND)
unnamed: C1.1, R10.1, R11.1, U4.1
unnamed: C1.2, R13.2
unnamed: C2.2, C3.1, R15.2, R16.1, R17.2, U4.7
unnamed: C3.2, R17.1, R18.2, R58.1
unnamed: C4.2, C5.1, R19.2, R21.1, U5.1
unnamed: C11.1, R39.1, R41.1, U8.1
unnamed: C11.2, R42.2
unnamed: C12.2, C13.1, R44.2, R45.1, R46.2, U8.7
unnamed: C13.2, R46.1, R47.2, R59.1
unnamed: C14.2, C15.1, R49.2, R50.1, U10.1
unnamed: D1.1 (A), J1.2, Q1.3 (D)
unnamed: D5.2 (A), R30.1
unnamed: D6.2 (A), R31.1
unnamed: D7.2 (A), R60.1
unnamed: D8.2 (A), R61.1
unnamed: J2.1, U3.13 (X)
unnamed: J2.3, U3.3 (Y)
unnamed: J4.1, Q3.3 (C)
unnamed: J4.2, R28.2
unnamed: J5.1, U6.13 (X)
unnamed: J5.3, U6.3 (Y)
unnamed: C17.2, J7.1, JP1.2 (B)
unnamed: J10.3, U1.7 (GPIO5)
unnamed: J10.4, U1.6 (GPIO4)
unnamed: J10.5, U1.5 (GPIO3)
unnamed: J10.6, U1.4 (GPIO2)
unnamed: J10.8, U1.2 (GPIO1)
unnamed: J10.9, U1.1 (GPIO0)
unnamed: Q1.1 (G), R1.1, R3.2
unnamed: Q2.3 (D), Q5.1 (G), R4.1
unnamed: Q2.1 (G), R2.2, R32.1
unnamed: Q3.1 (B), R29.1
unnamed: Q4.1 (G), U2.12
unnamed: Q6.1 (G), U9.12
unnamed: Q7.1 (B), R66.2
unnamed: Q7.3 (C), Q8.1 (G), R64.1
unnamed: R5.1, R6.1, U2.8
unnamed: R23.1, R25.2, R33.1, U2.1, U5.7
unnamed: R36.1, R40.1, U9.8
unnamed: R55.1, R56.2, R57.1, U9.1, U10.7
unnamed: U1.35 (ADC_VREF), U11.2 (OUT)
unnamed: U2.4, U2.5
unnamed: U2.3, U2.9, U2.10
unnamed: U2.2, U2.13
unnamed: R62.2, U3.10 (A)
unnamed: R8.2, U3.12 (X0)
unnamed: R5.2, U3.14 (X1)
unnamed: R9.1, U3.1 (Y0)
unnamed: R7.1, U2.6, U3.5 (Y1)
unnamed: R9.2, R12.1, U4.3 (+)
unnamed: R8.1, R10.2, U4.2 (-)
unnamed: R14.1, U4.5 (+)
unnamed: C2.1, R13.1, R15.1, U4.6 (-)
unnamed: R20.1, U5.3 (+)
unnamed: C4.1, R18.1, R19.1, U5.2 (-)
unnamed: R22.2, R23.2, U5.5 (+)
unnamed: C5.2, R24.2, U5.6 (-)
unnamed: R63.2, U6.10 (A)
unnamed: R34.2, U6.12 (X0)
unnamed: R36.2, U6.14 (X1)
unnamed: R35.1, U6.1 (Y0)
unnamed: R38.1, U6.5 (Y1), U9.6
unnamed: R35.2, R37.1, U8.3 (+)
unnamed: R34.1, R39.2, U8.2 (-)
unnamed: R43.1, U8.5 (+)
unnamed: C12.1, R42.1, R44.1, U8.6 (-)
unnamed: U9.4, U9.5
unnamed: U9.3, U9.9, U9.10
unnamed: U9.2, U9.13
unnamed: R48.1, U10.3 (+)
unnamed: C14.1, R47.1, R49.1, U10.2 (-)
unnamed: R52.2, R55.2, U10.5 (+)
unnamed: C15.2, R51.2, U10.6 (-)
unnamed: C22.2, U12.4 (BP)

Notes on the sheet:
Set to 9.5-9.6V At 12V it can't deliver the current needed for reliable solenoid actuation
*1) R25 to GND changed to +5V
POWER SEQUENCER to avoid inrush current during USB enumeration
ASSUMING MODIFIED TAKEUP REEL SENSOR CAS_TACHO connects to phototransistor's collector
*3) R23 changed to 1M
SX1308 DC-DC可调升压板
#NP-090 originally Changes marked with *#)
*2) 330K changed to 100K probably unimportant

Board: 2 copper layers, 84.3 x 64.5 mm, 136 parts (2 on the bottom side), 102 nets.

File hardware/tapeshnik-proto2/production/tapeshnik-proto_2023-08-20_15-52-43/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C11, C15, C22, C5",0805,5,0.1u,C49678
"C10, C16, C19, C20, C8, C9",0603,6,0.1u,C14663
"C12, C2",0805,2,180p,
"C13, C3",0805,2,2000p,
"C14, C4",0805,2,150p,
"C17, C18, C21, C6, C7",0805,5,10.0u/25V,
C23,CP_EIA-7343-31_Kemet-D,1,220.0/16V,
C24,CP_EIA-3528-21_Kemet-B,1,47.0/16V,
"D1, D2, D3, D4",SOT-23,4,BAT54S,
"Q1, Q2, Q4, Q6",SOT-23,4,AO3400,
Q3,SOT-23,1,S8050,
Q5,SOT-23,1,AP3101,
"R1, R12, R32, R37",0805,4,100K,
"R10, R17, R39, R46",0805,4,330K,
"R11, R16, R21, R41, R45, R50",0805,6,2K7,
"R13, R42",0805,2,6K8,
"R14, R15, R20, R43, R44, R48",0805,6,47K,
"R18, R47",0805,2,3K9,
"R19, R49",0805,2,56K,
"R2, R3, R62, R63",0805,4,47,
"R22, R24, R34, R35, R36, R5, R51, R52, R8, R9",0805,10,10K,
"R23, R55",0805,2,2M2,
"R25, R29, R56",0805,3,1K,
R26,0805,1,3K3,
R27,0805,1,2K2,
R28,0805,1,220,
"R30, R31, R38, R40, R6, R60, R7",0805,7,470,
"R33, R57, R58, R59",0805,4,N/C,
R4,0805,1,22K,
"R53, R54",0805,2,4K7,
R61,0805,1,760,

## KiCad design hardware/tapeshnik-mecha/foc/foc.kicad_pcb

File hardware/tapeshnik-mecha/foc/README.md:

# TAPESHNIK MOTOR CONTROL

This is a dual-BLDC controller aimed at spinning two BLDC motors of a tape transport.

It is designed with SimpleFOC in mind.

Big thanks to SimpleFOC community for support, reviews and inspiration!

  Controller: 				Waveshare RP2040-Zero
  Motor drivers: 			STSPIN233
  Tape speed sensor:			PMW3389

Parts:
C1, C6: 2.2uF/16V; C_0603_1608Metric
C2, C7: 22uF/16V; C_0805_2012Metric; LCSC C45783
C3, C4, C5, C8, C9, C10, C11: 0.1uF; C_0402_1005Metric
C12, C13: 10nF; C_0402_1005Metric
J1, J2, J5, J6: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x07; JST_SH_SM07B-SRSS-TB_1x07-1MP_P1.00mm_Horizontal
R1, R2, R6: 0.033/1W; R_2512_6332Metric; LCSC C2934109
R3, R4: 3K3; R_0603_1608Metric
R5: 0.033/1W; R_2512_6332Metric
R7, R8: 33K; R_0402_1005Metric
R9: 33K; R_0603_1608Metric
R10, R11: 3K3; R_0402_1005Metric
U1, U7: STSPIN233; VQFN-16-1EP_3x3mm_P0.5mm_EP1.8x1.8mm
U2, U4, U8, U9: INA181A1IDBVR; SOT-23-6
U3, U10: AS5047D; TSSOP-14_4.4x5mm_P0.65mm
U5: RP2040-Zero; rp2040-zero

Connections:
+3V3: C3.1, C4.1, C5.1, C8.1, C9.1, C10.1, C11.1, J4.1, J6.2, R3.1, R7.1, R8.1, R10.1, R11.1, U2.6 (V+), U3.11 (VDD), U3.12 (VDD3V3), U4.6 (V+), U5.2 (3V3), U8.6 (V+), U9.6 (V+), U10.11 (VDD), U10.12 (VDD3V3)
+9V: C1.1, C2.1, C6.1, C7.1, J3.1, U1.5 (VS), U7.5 (VS)
/5V_VBUS: J6.1, U5.0 (5V)
/CSREF: R3.2, R4.1, U2.5 (REF), U4.5 (REF), U8.5 (REF), U9.5 (REF)
/MISO: J4.7, U3.3 (MISO), U5.10 (GP12), U10.3 (MISO)
/MOSI: J4.6, U3.4 (MOSI), U5.11 (GP11), U10.4 (MOSI)
/PMW3660_RESET: J4.3, U5.15 (GP7)
/PWM1_U: U1.1 (INU), U5.19 (GP3)
/PWM1_V: U1.15 (INV), U5.18 (GP4)
/PWM1_W: U1.11 (INW), U5.17 (GP5)
/PWM2_U: U5.22 (GP0), U7.1 (INU)
/PWM2_V: U5.21 (GP1), U7.15 (INV)
/PWM2_W: U5.20 (GP2), U7.11 (INW)
/SCK: J4.5, U3.2 (CLK), U5.12 (GP10), U10.2 (CLK)
/SENSEV1: U4.1, U5.3 (GP29)
/SENSEV2: U5.6 (GP26), U8.1
/SENSEW1: U2.1, U5.4 (GP28)
/SENSEW2: U5.5 (GP27), U9.1
/UART1_RX: J2.1, U5.13 (GP9)
/UART1_TX: J2.2, U5.14 (GP8)
/~PMW3660_CS: J4.4, U5.16 (GP6)
/~SSI_CS1: U3.1 (~CS), U5.9 (GP13)
/~SSI_CS2: U5.8 (GP14), U10.1 (~CS)
/~STANDBY: R9.1, U1.14 (STBY/RESET), U5.7 (GP15), U7.14 (STBY/RESET)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J2.3, J3.2, J4.2, J6.3, R4.2, R9.2, U1.4 (SENSEU), U1.6 (GND), U1.8 (SENSEV), U1.9 (SENSEW), U1.17 (GND), U2.2 (GND), U3.5 (TST), U3.13 (GND), U4.2 (GND), U5.1 (GND), U7.4 (SENSEU), U7.6 (GND), U7.8 (SENSEV), U7.9 (SENSEW), U7.17 (GND), U8.2 (GND), U9.2 (GND), U10.5 (TST), U10.13 (GND)
unnamed: J1.1, U7.3 (OUTU)
unnamed: J1.2, R5.2, U8.4 (-)
unnamed: J1.3, R6.2, U9.4 (-)
unnamed: J5.1, U1.3 (OUTU)
unnamed: J5.2, R2.2, U4.4 (-)
unnamed: J5.3, R1.2, U2.4 (-)
unnamed: R10.2, U1.2 (ENU), U1.12 (ENW), U1.16 (ENV)
unnamed: C13.1, R8.2, U1.13 (EN/FAULT)
unnamed: R2.1, U1.7 (OUTV), U4.3 (+)
unnamed: R1.1, U1.10 (OUTW), U2.3 (+)
unnamed: R11.2, U7.2 (ENU), U7.12 (ENW), U7.16 (ENV)
unnamed: C12.1, R7.2, U7.13 (EN/FAULT)
unnamed: R5.1, U7.7 (OUTV), U8.3 (+)
unnamed: R6.1, U7.10 (OUTW), U9.3 (+)

Notes on the sheet:
Optical Sensor
MOTOR2
MOTOR1
MOTOR POWER

Board: 2 copper layers, 82.0 x 43.5 mm, 39 parts (4 on the bottom side), 39 nets.

Notices in the files:
hardware/tapeshnik-mecha/pwm3389_pcb_edge/pwm3389_pcb_edge.kicad_pcb:
MIT License, Open Source Hardware
